Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2025-06-20T15:38:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.90.15 - Exporter 21.1.90.15 - Alternate UI 21.1.90.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 20 15:38:37 2025 * Host: STB002 * Database: C:\Users\LARISS~1\AppData\Local\Temp\234e31d9-e186-458c-9206-d387dea7a233\c1cd0dc3-98cf-4115-ab2f-a9548216a2dc\ifc * Database version: 5507 * Database creation date: Fri Jun 20 15:38:37 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 20 15:38:37 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 20 15:38:37 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcCovering: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01:REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-ALLOY, REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01:REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-ALLOY:281912
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - Material: Grés porcelânico; TotalThickness: 10.5 mm; Finish: REVIGRÉS-RULE-DGCFCANTO-30x60-SILK-ALLOY
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Generic Models
Type - IFC.REVIGRÉS-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Generic Model - AlturaNominal: 10.5 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - ItemEParcialmenteReciclado: 0; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Generic Model - Nome: REVIGRES-RULE-DG CF CANTO ESQUERDO-30X60-SILK-ALLOY; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Material: REVIGRÉS-RULE-DGCFCANTO-30x60-SILK-ALLOY
IFC.REVIGRÉS-Dados do fabricante-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-ALLOY
IFC.REVIGRÉS-Dados de desempenho-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-ALLOY
IFC.REVIGRÉS-Dados de especificação-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-ALLOY
IFC.REVIGRÉS-Dados geométricos-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-ALLOY
IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-ALLOY

# IfcCovering: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01:REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-SMOG, REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01:REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-SMOG:284547
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - Material: Grés porcelânico; TotalThickness: 10.5 mm; Finish: REVIGRÉS-RULE-DGCFCANTO-30x60-SILK-SMOG
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Generic Models
Type - IFC.REVIGRÉS-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Generic Model - AlturaNominal: 10.5 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemEParcialmenteReciclado: 0.23; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Generic Model - Nome: REVIGRES-RULE-DG CF CANTO ESQUERDO-30X60-SILK-SMOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Material: REVIGRÉS-RULE-DGCFCANTO-30x60-SILK-SMOG
IFC.REVIGRÉS-Dados do fabricante-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-SMOG
IFC.REVIGRÉS-Dados de desempenho-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-SMOG
IFC.REVIGRÉS-Dados de especificação-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-SMOG
IFC.REVIGRÉS-Dados geométricos-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-SMOG
IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SILK-SMOG

# IfcCovering: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01:REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-ALLOY, REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01:REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-ALLOY:284261
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - Material: Grés porcelânico; TotalThickness: 10.5 mm; Finish: REVIGRÉS-RULE-DGCFCANTO-30x60-SOFT GRIP-ALLOY
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Generic Models
Type - IFC.REVIGRÉS-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SOFT GRIP; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: >36; ResistenciaAoDeslizamentoBS7976: >36; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Generic Model - AlturaNominal: 10.5 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - ItemEParcialmenteReciclado: 0; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Generic Model - Nome: REVIGRES-RULE-DG CF CANTO ESQUERDO-30X60-SOFT GRIP-ALLOY; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Material: REVIGRÉS-RULE-DGCFCANTO-30x60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados do fabricante-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de desempenho-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de especificação-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados geométricos-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-ALLOY

# IfcCovering: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01:REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-SMOG, REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01:REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-SMOG:284548
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - Material: Grés porcelânico; TotalThickness: 10.5 mm; Finish: REVIGRÉS-RULE-DGCFCANTO-30x60-SOFT GRIP-SMOG
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Generic Models
Type - IFC.REVIGRÉS-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SOFT GRIP; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: >36; ResistenciaAoDeslizamentoBS7976: >36; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Generic Model - AlturaNominal: 10.5 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; ItemEParcialmenteReciclado: 0.23; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Generic Model - Nome: REVIGRES-RULE-DG CF CANTO ESQUERDO-30X60-SOFT GRIP-SMOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Material: REVIGRÉS-RULE-DGCFCANTO-30x60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados do fabricante-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de desempenho-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de especificação-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados geométricos-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de sustentabilidade-Generic Model - Type: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-R21-v01: REVIGRÉS-RULE-DGCF CANTO ESQUERDO-30X60-SOFT GRIP-SMOG
