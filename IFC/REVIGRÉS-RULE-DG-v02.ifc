Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2025-06-20T15:38:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.90.15 - Exporter 21.1.90.15 - Alternate UI 21.1.90.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 20 15:38:34 2025 * Host: STB002 * Database: C:\Users\LARISS~1\AppData\Local\Temp\234e31d9-e186-458c-9206-d387dea7a233\a306206e-6ff5-4464-a759-aa5d639e2548\ifc * Database version: 5507 * Database creation date: Fri Jun 20 15:38:34 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 20 15:38:34 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 20 15:38:34 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcCovering: Floor:REVIGRÉS-RULE-DG-30x120-SILK-ALLOY, Floor:REVIGRÉS-RULE-DG-30x120-SILK-ALLOY:11621
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-30x120-SILK-ALLOY 10.5 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 118.6 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - ItemEParcialmenteReciclado: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-30X120-SILK-ALLOY; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 10.5 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SILK-ALLOY
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SILK-ALLOY
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SILK-ALLOY
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SILK-ALLOY
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SILK-ALLOY

# IfcCovering: Floor:REVIGRÉS-RULE-DG-30x120-SILK-SMOG, Floor:REVIGRÉS-RULE-DG-30x120-SILK-SMOG:12138
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-30x120-SILK-SMOG 10.5 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 118.6 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-30X120-SILK-SMOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 10.5 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SILK-SMOG
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SILK-SMOG
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SILK-SMOG
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SILK-SMOG
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SILK-SMOG

# IfcCovering: Floor:REVIGRÉS-RULE-DG-30x120-SOFT GRIP-ALLOY, Floor:REVIGRÉS-RULE-DG-30x120-SOFT GRIP-ALLOY:11684
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-30x120-SOFT GRIP-ALLOY 10.5 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SOFT GRIP; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: >36; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: >36; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 118.6 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - ItemEParcialmenteReciclado: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-30X120-SOFT GRIP-ALLOY; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 10.5 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SOFT GRIP-ALLOY

# IfcCovering: Floor:REVIGRÉS-RULE-DG-30x120-SOFT GRIP-SMOG, Floor:REVIGRÉS-RULE-DG-30x120-SOFT GRIP-SMOG:12147
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-30x120-SOFT GRIP-SMOG 10.5 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SOFT GRIP; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: >36; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: >36; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 118.6 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-30X120-SOFT GRIP-SMOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 10.5 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x120-SOFT GRIP-SMOG

# IfcCovering: Floor:REVIGRÉS-RULE-DG-30x60-SILK-ALLOY, Floor:REVIGRÉS-RULE-DG-30x60-SILK-ALLOY:11762
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-30x60-SILK-ALLOY 11.2 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - ItemEParcialmenteReciclado: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-30X60-SILK-ALLOY; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 11.2 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SILK-ALLOY
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SILK-ALLOY
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SILK-ALLOY
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SILK-ALLOY
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SILK-ALLOY

# IfcCovering: Floor:REVIGRÉS-RULE-DG-30x60-SILK-SMOG, Floor:REVIGRÉS-RULE-DG-30x60-SILK-SMOG:12156
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-30x60-SILK-SMOG 11.2 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-30X60-SILK-SMOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 11.2 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SILK-SMOG
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SILK-SMOG
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SILK-SMOG
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SILK-SMOG
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SILK-SMOG

# IfcCovering: Floor:REVIGRÉS-RULE-DG-30x60-SOFT GRIP-ALLOY, Floor:REVIGRÉS-RULE-DG-30x60-SOFT GRIP-ALLOY:11771
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-30x60-SOFT GRIP-ALLOY 11.2 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SOFT GRIP; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: >36; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: >36; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - ItemEParcialmenteReciclado: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-30X60-SOFT GRIP-ALLOY; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 11.2 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SOFT GRIP-ALLOY

# IfcCovering: Floor:REVIGRÉS-RULE-DG-30x60-SOFT GRIP-SMOG, Floor:REVIGRÉS-RULE-DG-30x60-SOFT GRIP-SMOG:12164
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-30x60-SOFT GRIP-SMOG 11.2 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SOFT GRIP; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: >36; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: >36; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 29.5 mm; LarguraNominal: 59.2 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-30X60-SOFT GRIP-SMOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 11.2 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-30x60-SOFT GRIP-SMOG

# IfcCovering: Floor:REVIGRÉS-RULE-DG-45x90-SILK-ALLOY, Floor:REVIGRÉS-RULE-DG-45x90-SILK-ALLOY:11306
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-45x90-SILK-ALLOY 10.5 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 44.35 mm; LarguraNominal: 88.9 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - ItemEParcialmenteReciclado: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-45X90-SILK-ALLOY; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 10.5 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SILK-ALLOY
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SILK-ALLOY
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SILK-ALLOY
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SILK-ALLOY
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SILK-ALLOY

# IfcCovering: Floor:REVIGRÉS-RULE-DG-45x90-SILK-SMOG, Floor:REVIGRÉS-RULE-DG-45x90-SILK-SMOG:11369
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-45x90-SILK-SMOG 10.5 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 44.35 mm; LarguraNominal: 88.9 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-45X90-SILK-SMOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 10.5 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SILK-SMOG
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SILK-SMOG
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SILK-SMOG
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SILK-SMOG
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SILK-SMOG

# IfcCovering: Floor:REVIGRÉS-RULE-DG-45x90-SOFT GRIP-ALLOY, Floor:REVIGRÉS-RULE-DG-45x90-SOFT GRIP-ALLOY:11431
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-45x90-SOFT GRIP-ALLOY 10.5 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SOFT GRIP; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: >36; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: >36; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 44.35 mm; LarguraNominal: 88.9 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - ItemEParcialmenteReciclado: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-45X90-SOFT GRIP-ALLOY; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 10.5 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SOFT GRIP-ALLOY

# IfcCovering: Floor:REVIGRÉS-RULE-DG-45x90-SOFT GRIP-SMOG, Floor:REVIGRÉS-RULE-DG-45x90-SOFT GRIP-SMOG:11517
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-45x90-SOFT GRIP-SMOG 10.5 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SOFT GRIP; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: >36; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: >36; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 44.35 mm; LarguraNominal: 88.9 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-45X90-SOFT GRIP-SMOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 10.5 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SOFT GRIP-SMOG
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-45x90-SOFT GRIP-SMOG

# IfcCovering: Floor:REVIGRÉS-RULE-DG-60x120-SILK-ALLOY, Floor:REVIGRÉS-RULE-DG-60x120-SILK-ALLOY:11872
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-60x120-SILK-ALLOY 10.5 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 59.2 mm; LarguraNominal: 118.6 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - ItemEParcialmenteReciclado: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-60X120-SILK-ALLOY; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 10.5 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SILK-ALLOY
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SILK-ALLOY
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SILK-ALLOY
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SILK-ALLOY
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SILK-ALLOY

# IfcCovering: Floor:REVIGRÉS-RULE-DG-60x120-SILK-SMOG, Floor:REVIGRÉS-RULE-DG-60x120-SILK-SMOG:12174
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-60x120-SILK-SMOG 10.5 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SILK; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R9; ResistenciaAoEscorregamentoDIN51097: A; ResistenciaAoEscorregamentoENV51097: A; ResistenciaAoEscorregamentoENV12633: Class 1; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 1; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 59.2 mm; LarguraNominal: 118.6 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.23; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-60X120-SILK-SMOG; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 10.5 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SILK-SMOG
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SILK-SMOG
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SILK-SMOG
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SILK-SMOG
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SILK-SMOG

# IfcCovering: Floor:REVIGRÉS-RULE-DG-60x120-SOFT GRIP-ALLOY, Floor:REVIGRÉS-RULE-DG-60x120-SOFT GRIP-ALLOY:11880
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-60x120-SOFT GRIP-ALLOY 10.5 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SOFT GRIP; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
Type - IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.2% máx.± 0.8 mm; Ortogonalidade: ± 0.2% máx.± 1.5 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: >3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R11; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: >36; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: >36; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
Type - IFC.REVIGRÉS-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 5; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
Type - IFC.REVIGRÉS-Dados geométricos-Floor Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 59.2 mm; LarguraNominal: 118.6 mm
Type - IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - ItemEParcialmenteReciclado: 0; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEReciclado: Não; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
Type - IFC.REVIGRÉS-Dados gerais-Floor Covering - Nome: REVIGRÉS-RULE-DG-60X120-SOFT GRIP-ALLOY; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
Classification: C3020 (Uniformat)
Pset_CoveringCommon - TotalThickness: 10.5 mm
IFC.REVIGRÉS-Dados do fabricante-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de desempenho-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de especificação-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados geométricos-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SOFT GRIP-ALLOY
IFC.REVIGRÉS-Dados de sustentabilidade-Floor Covering - Type: Floor: REVIGRÉS-RULE-DG-60x120-SOFT GRIP-ALLOY

# IfcCovering: Floor:REVIGRÉS-RULE-DG-60x120-SOFT GRIP-SMOG, Floor:REVIGRÉS-RULE-DG-60x120-SOFT GRIP-SMOG:12182
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRÉS-RULE-DG-60x120-SOFT GRIP-SMOG 10.5 mm
Type - Pset_CoveringCommon - Material: Grés porcelânico
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRÉS
Type - Pset_ProductRequirements - Category: Floors
Type - IFC.REVIGRÉS-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Rule; Acabamento: SOFT GRIP; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/rule; PaisOrigem: Portugal
